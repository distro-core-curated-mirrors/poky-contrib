PACKAGECONFIG_append_pn-qemu-native = " virtfs"
