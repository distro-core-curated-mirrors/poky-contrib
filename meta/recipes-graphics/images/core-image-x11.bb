DESCRIPTION = "A very basic X11 image with a terminal"

IMAGE_FEATURES += "splash package-management x11-base"

LICENSE = "MIT"

<<<<<<< HEAD
inherit core-image distro_features_check

REQUIRED_DISTRO_FEATURES = "x11"
=======
inherit core-image
>>>>>>> cb9658cf8ab6cf009030dcadde9dc6c54b72bddc
