require xcb-util.inc

DEPENDS += "xcb-util"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://image/xcb_image.c;endline=24;md5=eafdf965cfb89955fdedf75054223fb4 \
<<<<<<< HEAD
                    file://image/xcb_image.h;beginline=4;endline=27;md5=48cd25ae55e7de525fe1e1a3a7672e1c"
=======
                    file://image/xcb_image.h;startline=4;endline=27;md5=4e4f1b0fae5694beed407dea01f38212"
>>>>>>> cb9658cf8ab6cf009030dcadde9dc6c54b72bddc
PR = "r0"

SRC_URI[md5sum] = "fabb80b36490b00fc91289e2c7f66770"
SRC_URI[sha256sum] = "d35a3c0eaae171f5081ec127fb9cec174b716ce5d78196a87f2785376da021df"

