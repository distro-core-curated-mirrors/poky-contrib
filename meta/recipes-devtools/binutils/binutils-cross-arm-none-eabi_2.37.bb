require binutils.inc
require binutils-${PV}.inc
require binutils-cross.inc

TARGET_ARCH = "arm"
TARGET_VENDOR = "-none"
TARGET_OS = "eabi"

