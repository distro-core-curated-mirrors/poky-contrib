require recipes-devtools/gcc/gcc-${PV}.inc
require gcc-cross.inc

TARGET_ARCH = "arm"
TARGET_VENDOR = "-none"
TARGET_OS = "eabi"

