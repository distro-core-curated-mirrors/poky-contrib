require recipes-devtools/gcc/gcc-cross-initial_${PV}.bb
require gcc-crosssdk-initial.inc
<<<<<<< HEAD
=======
EXTRA_OECONF += " --with-native-system-header-dir=${SYSTEMHEADERS} "
>>>>>>> cb9658cf8ab6cf009030dcadde9dc6c54b72bddc

