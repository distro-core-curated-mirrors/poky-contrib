require python-magic.inc

DEPENDS_class-native += "python-setuptools-native"

inherit setuptools
