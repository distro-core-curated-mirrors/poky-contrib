require python-libarchive-c.inc

inherit setuptools
