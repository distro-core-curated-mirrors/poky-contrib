require python-magic.inc

DEPENDS_class-native += "python3-setuptools-native"

inherit setuptools3
