SUMMARY = "Virtual provider sysroot test"
LICENSE = "CLOSED"
INHIBIT_DEFAULT_DEPS = "1"
DEPENDS = "virtual/sysroot-test"
