KERNEL_PACKAGE_NAME = "rt-linux"
