KERNEL_PACKAGE_NAME = "tiny-linux"
