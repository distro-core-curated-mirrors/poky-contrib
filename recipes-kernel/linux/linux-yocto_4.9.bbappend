FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "netfilter.cfg"
