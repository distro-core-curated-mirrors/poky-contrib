require recipes-devtools/gcc/gcc-4.8arc.inc
require recipes-devtools/gcc/gcc-source.inc
