COMPATIBLE_MACHINE:generic-arm64 = "generic-arm64"
KMACHINE:generic-arm64 = "qemuarm64"

# TODO bruce will kill me for this
#KBUILD_DEFCONFIG:generic-arm64 = "defconfig"
#KCONFIG_MODE:generic-arm64 = "--alldefconfig"
